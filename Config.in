## Config.in
```kconfig
menu "TinyDrcom configuration"
	depends on PACKAGE_tinydrcom

config TINYDRCOM_DEBUG
	bool "Enable Debug Output"
	default N

endmenu
```
